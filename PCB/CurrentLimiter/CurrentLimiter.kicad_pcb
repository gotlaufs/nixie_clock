# Repository gotlaufs/nixie_clock

File README.md:

# Yet another nixie clock
This is a nixie clock project using some salvaged Russian IN-14 nixie tubes.

## KiCad design PCB/CurrentLimiter/CurrentLimiter.kicad_pcb

Parts:
D1: 1N4148; D_SOD-123
P1: Signals; Pin_Header_Straight_1x06_Pitch2.54mm
P2: OpAmp1-4; Pin_Header_Straight_1x04_Pitch2.54mm
P3: OpAmp5-8; Pin_Header_Straight_1x04_Pitch2.54mm
Q1: Q_PMOS_GSD; SOT-23_Handsoldering
Q2, Q3, Q4: Q_NPN_BEC; SOT-23_Handsoldering
R1: 15k; R_0805_HandSoldering
R2, R5: 10k; R_0805_HandSoldering
R3: 2.2k; R_0805_HandSoldering
R4, R8, R11, R12: 1k; R_0805_HandSoldering
R6: 47k; R_0805_HandSoldering
R7: 12k; R_0805_HandSoldering
R9, R10: 20k; R_0805_HandSoldering
U1: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
W1, W2, W3: TEST_1P; Measurement_Point_Round-SMD-Pad_Big

Connections:
+12V: P1.4, P2.4, Q1.2 (S), R1.1, U1.4 (V-)
/OC_signal: P2.1, R6.1, R7.2, U1.1, W2.1
/OpA+: P2.3, R7.1, R8.2, U1.3 (+)
/OpB+: P3.4, R10.2, R12.2, U1.5 (+)
/OpB-: P3.3, R9.1, R11.2, U1.6 (-)
/Vbase: Q2.1 (B), Q3.3 (C), R2.2, R3.1, R4.2, W1.1
/Vdiff: P3.2, R8.1, R9.2, U1.7, W3.1
GND: P1.3, P3.1, Q2.2 (E), Q3.2 (E), Q4.2 (E), R3.2, R10.1, U1.8 (V+)
unnamed: D1.1 (K), R4.1
unnamed: Q1.1 (G), Q2.3 (C), R1.2
unnamed: Q3.1 (B), Q4.3 (C), R6.2
unnamed: Q4.1 (B), R5.2
ON: D1.2 (A), P1.2, R5.1
V+: P1.6, R12.1
V-: P1.7, R11.1
Vout: P1.5, Q1.3 (D), R2.1
Vref: P1.1, P2.2, U1.2 (-)

Notes on the sheet:
Q2-Q4 General purpose NPN transistors
U1 General purpose single supply dual Op Amp with Vcc of +12V.

Board: 2 copper layers, 39.0 x 29.0 mm, 24 parts (0 on the bottom side), 17 nets.

## KiCad design PCB/PSU/PSU_v1.kicad_pcb

Parts:
C1: 680p; C_0805_HandSoldering
C2: 220u; CP_Elec_8x10.5
C3: 0.01u; C_0805_HandSoldering
C4: 2.2u; CP_Elec_10x10.5
D1: 1N914; D_SOD-123
D2: BAS21; SOT-23_Handsoldering
J1: CONN_01X05; Pin_Header_Straight_1x05_Pitch2.54mm
L1: 150u; Choke_SMD_Wuerth-WE-PD-Typ-LS_Handsoldering
Q1: MPSA55; SOT-23_Handsoldering
Q2: IRF630; TO-252-2Lead
R1, R2: 0.5R; R_1210_HandSoldering
R3: 1k; R_0805_HandSoldering
R4: 475k; R_0603_HandSoldering
R5: 13.7k; R_0603_HandSoldering
R6: 4.02k; R_0805_HandSoldering
R7: R; R_0805_HandSoldering
RV1: 100k; Potentiometer_Trimmer_Bourns_3214G
U1: MC34063; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+12V: J1.1, R1.2, R2.2, U1.6 (VCC)
/Rx: J1.5, R6.1, R7.2, RV1.1
/Vout: C4.1, D2.3 (K), J1.4, R4.1
/Vpulse: D2.1 (A), J1.3, L1.2, Q2.2 (D)
GND: C1.2, C2.2, C3.2, C4.2, J1.2, Q1.3 (C), Q2.3 (S), R3.2, R5.2, R7.1, RV1.2, U1.4 (GND)
unnamed: C1.1, U1.3 (C_t)
unnamed: C2.1, L1.1, R1.1, R2.1, U1.1 (Cs), U1.7 (Is), U1.8 (Cd)
unnamed: C3.1, R4.2, R5.1, R6.2, U1.5 (CMP)
unnamed: D1.1 (K), Q1.2 (E), Q2.1 (G)
unnamed: D1.2 (A), Q1.1 (B), R3.1, U1.2 (Es)

Notes on the sheet:
Calibrate with RV1 and leave only R7 in final design.
R7 = (772.4-4Vout)/(Vout-44.6)
Vout = 44.6 + 594/(4+R7); R7 in kOhms
Notes: Q1 generic PNP [KSP2907] Q2 generic MOSFET [IRF740; IRFD220] D1 NXP BAV21 or MUR140 (50 ns, 300 mA) D2 1N914 or 1N4148 (4 ns; 300 mA)

Board: 2 copper layers, 42.5 x 38.7 mm, 19 parts (0 on the bottom side), 10 nets.

## KiCad design Hardware/CurrentLimiter/CurrentLimiter_DaughterBoard.kicad_pcb

Board: 2 copper layers, 17.0 x 11.0 mm, 3 parts (0 on the bottom side), 8 nets.

Parts:
P2: OpAmp1-4; Pin_Header_Straight_1x04_Pitch2.54mm
P3: OpAmp5-8; Pin_Header_Straight_1x04_Pitch2.54mm
U1: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+12V: P2.4, U1.4
/OC_signal: P2.1, U1.1
/OpA+: P2.3, U1.3
/OpB+: P3.4, U1.5
/OpB-: P3.3, U1.6
/Vdiff: P3.2, U1.7
GND: P3.1, U1.8
Vref: P2.2, U1.2

## KiCad design Hardware/PSU_v2/PSU_v2.kicad_pcb

Board: 2 copper layers, 48.0 x 41.5 mm, 30 parts (0 on the bottom side), 12 nets.

Parts:
C1: 680p; C_0805_HandSoldering
C2: 220u; CP_Elec_8x10.5
C3: 0.01u; C_0805_HandSoldering
C4: 2.2u; CP_Elec_10x10.5
D1: 1N914; D_SOD-123
D2: BAS21; SOT-23_Handsoldering
J1: CONN_01X05; Pin_Header_Straight_1x05_Pitch2.54mm
L1: 150u; Choke_SMD_Wuerth-WE-PD-Typ-LS_Handsoldering
Q1: MPSA55; SOT-23_Handsoldering
Q2: IRF630; TO-263-2Lead
R1, R2: 0.5R; R_1210_HandSoldering
R3: 1k; R_0805_HandSoldering
R4: 330k; R_0805_HandSoldering
R5: 3.3k; R_0805_HandSoldering
R6: 5.6k; R_0805_HandSoldering
R7: R; R_0805_HandSoldering
R8, R9: 0R; R_0805_HandSoldering
RV1: 100k; Potentiometer_Trimmer_Bourns_3214G
U1: MC34063; SOIC-8_3.9x4.9mm_Pitch1.27mm
W1, W3, W4, W5, W7, W8, W9, W10, W11: TEST_1P; Measurement_Point_Round-SMD-Pad_Small

Connections:
+12V: J1.3, R1.2, R2.2, U1.6, W1.1
/MC_CMP: C3.1, R4.2, R5.1, R6.2, U1.5, W5.1
/MC_C_t: C1.1, U1.3, W3.1
/MC_Cd: R8.1, U1.8, W10.1
/MC_Cs: R9.1, U1.1, W4.1
/MC_Es: D1.2, Q1.1, R3.1, U1.2, W11.1
/MOSFET_G: D1.1, Q1.2, Q2.1, W9.1
/Rx: J1.5, R6.1, R7.2, RV1.3, W8.1
/Vout: C4.1, D2.3, J1.4, R4.1, W7.1
/Vpulse: D2.1, J1.2, L1.2, Q2.2
GND: C1.2, C2.2, C3.2, C4.2, J1.1, Q1.3, Q2.3, R3.2, R5.2, R7.1, RV1.2, U1.4
unnamed: C2.1, L1.1, R1.1, R2.1, R8.2, R9.2, U1.7

## Commit log

2017-02-08 HV power supply prototype PCB
2017-02-12 Small additions to HV PSU schematic
2017-02-13 Some little additions to footprints
2017-02-15 PCB layout for the HV PSU prototype
2017-02-16 Microscopic trace delete
2017-02-16 Some tweaks to schematic and PCB based on laser etching prototyping
2017-02-17 Edits to some component footprints due to component availability
2017-02-25 Made J1 pads bigger for easier drilling
2017-02-25 BoM for HV PSU prototype
2017-03-01 LTSpice simulation files
2017-03-01 App note for MC34063 regulator
2017-03-01 Newer KiCad format and gitignore for LTSpice
2017-03-10 Make space for the next prototype
2017-03-10 Some reflections on the first HV PSU prototype
2017-03-10 Todo update
2017-03-10 Initial files for HV PSU v2 prototype
2017-03-19 Corrected MOSFET footprint, added test points, made resistor values sane. Also some comments on over-current protection
2017-03-20 PCB for HV PSU v2 prototype
2017-03-28 Added exports for the v2 of HV PCB
2017-03-28 Simulation files for over-current protection
2017-04-02 Initial KiCad schematic for Current Limiter prototype
2017-04-05 Footprints for transistors added
2017-04-05 Datasheets for transistors added
2017-04-05 Added header connectors for OpAmp modules
2017-04-05 Initial over-current PCB layout file
2017-04-06 Overcurrent protection proto PCB mostly done
2017-04-09 Some minor cleanups for OC proto PCB. Added OPAmp daughter board PCB
2017-04-29 Eagle files
    Eagle project files
2017-04-29 Moved Eagle files into appropriate dir
2017-04-29 Fixing minor schematic issues (anode resistors and cap values in 3v3 PSU). Updated gitignore with EAGLE temp files
2017-04-29 Most of HV supply schematic done. Need to pick transistors, caps and diode
2017-05-01 HV PSU schematic captured. Still need to pick correct pot
2017-05-02 Added Buttons
    Added 4 buttons and two strip for connectors. buttons are on the last
    alb gpios. removed connections for DOT_LED
2017-05-03 Changed ESP8266
    changed esp8266 footprint
2017-05-07 Brought Anode resistors to the lower PCB
2017-05-07 Added cheaper 3V3 PSU
2017-05-07 Added optional RTC module and cleaned up the schematic
2017-05-09 Added some footprints
2017-05-09 Rebuilt boards
    Boards are in the correct 150*80 format. repositioned b2b connectors
2017-05-09 Added some more component footprints
2017-05-10 Starting to do layout
2017-05-10 Some more routing
2017-05-10 Routing the PCB
2017-05-11 Top board first route
2017-05-11 Gottom board routing mostly done
2017-05-11 Some more tob board routing
2017-05-11 Mechanical drawing for top and bottom
2017-05-12 Proto for Hinge and first test for enclosure
    Top and bottom SBOK while lateral side needs testing, should fit tough
2017-05-12 Enclosure rev1 finished
2017-05-12 Started fixing nixie tube footprint
2017-05-12 Board 3d and mechanics done
2017-05-13 small fixes
2017-05-13 Top board touting complete
2017-05-13 Added some values to components in schematic
2017-05-15 update on 3d pcb
2017-05-15 hinge rev2.0
2017-05-15 old auto cad version
2017-05-15 fixed hinge
2017-05-15 fixed hinge and saved correctly
2017-05-15 Move mechanical stuff around
2017-05-15 Rename PCB dir appropriately
2017-05-15 Some simulations on beefier 3V3 PSU
2017-05-16 new hinge test
2017-05-16 changed original hinge to 9 taps
2017-05-16 changes to mechanical
    new hinge design for testing. Still breaks
2017-05-16 changed auto cad sw version
2017-05-16 modified wave pattern
2017-05-16 Wave pattern update
2017-05-16 Updated file type
2017-05-16 new test wave
2017-05-18 Modified both switching PSUs for the new VFD requirements
2017-05-18 Modified IN-14 device to accomodate IV-11 VFD
2017-05-18 Added Eagle libraries for components. New symbols for Solder bridge and cut trace comps
2017-05-18 Hopefully fixed compined tube footprint for good
2017-05-18 Added stuff for 1V5 rail for VFD cathodes
2017-05-18 Figured out how to wire up tubes to support both IN-14 and IV-11
2017-05-19 Finished tube schematic layout
2017-05-19 Some initial experimental routing for the top board
2017-05-20 Some more routing of the top board
2017-06-04 Top board routing
2017-06-06 More Tob Board Routing
2017-06-06 Bottom board routing. Some DRC errors remain.
2017-06-13 Most of the board done
2017-06-13 Silk screen touch ups
2017-06-13 More tweaks to silk screen
2017-06-13 CAM job file and first version of Gerbers
